# Keil uVision project JDQD.uvprojx, settings and files
target JDQD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L475RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: XJTU +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ..\USER;..\CORE;..\HALLIB\STM32L4xx_HAL_Driver\Inc;..\HALLIB\STM32L4xx_HAL_Driver\Inc\Legacy;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\EXTI;..\HARDWARE\IWDG;..\HARDWARE\WWDG;..\HARDWARE\TIMER;..\HARDWARE\PWM;..\HARDWARE\LCD;..\HARDWARE\SPI2;..\USMART;..\HARDWARE\RTC;..\HARDWARE\RNG;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\GPIO;..\HARDWARE\LORA\src;..\HARDWARE\LORA\inc;..\HARDWARE\DMA;..\HARDWARE\DS18;..\SYSTEM\RingBuffer;..\HARDWARE\GPS;..\HARDWARE\MYIIC;..\HARDWARE\MLX90614
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group USER
    ./: main.c stm32l4xx_it.c system_stm32l4xx.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32l475xx.s
  group HALLIB
    ../HALLIB/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/usart/: usart.c usart.h
    ../SYSTEM/RingBuffer/: RingBuffer.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c adc.h
    ../HARDWARE/GPIO/: gpio.c gpio.h
    ../HARDWARE/SPI2/: spi2.c spi2.h
    ../HARDWARE/DMA/: dma.c dma.h
    ../HARDWARE/DS18/: DS18.c DS18.h
    ../HARDWARE/GPS/: GPS.c GPS.h
    ../HARDWARE/MYIIC/: myiic.c myiic.h
    ../HARDWARE/MLX90614/: MLX90614.c MLX90614.h
    ../HARDWARE/TIMER/: tim.c
  group Lora
    ../HARDWARE/LORA/src/: crc.c radio.c sx126x.c sx126x-board.c
